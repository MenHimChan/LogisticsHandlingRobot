# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\PULSE;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\LobotServoController;..\HARDWARE\usart2_gm65;..\HARDWARE\USART-HMI;..\SYSTEM\uart;..\TRACK;..\HARDWARE\uart5_jy61p;..\HARDWARE\UART4_OPENMV;..\Timer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/uart/: uart.c
  group README
    ../: README.TXT
  group PULSE
    ../PULSE/: PULSE.c PULSE.h
  group HARDWARE
    ../HARDWARE/KEY/: key.c key.h
    ../HARDWARE/LED/: led.c led.h
    ../HARDWARE/LobotServoController/: bool.h LobotServoController.c LobotServoController.h
    ../HARDWARE/usart2_gm65/: USART2_GM65.C USART2_GM65.H
    ../HARDWARE/USART-HMI/: usart-hmi.c usart-hmi.h
  group TRACK
    ../TRACK/: Track.c Track.h
  group USART5
    ../HARDWARE/uart5_jy61p/: JY61.h uart5_jy61p.c uart5_jy61p.h
  group USART4_OPENMV
    ../HARDWARE/UART4_OPENMV/: UART4_OPENMV.c UART4_OPENMV.h
  group Timer
    ../Timer/: timer.c timer.h
